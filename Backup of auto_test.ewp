# IAR project Backup of auto_test.ewp, settings and files
configuration Debug (ARM, debug)
  group Core
    Core/: main.c stm32f10x_it.c startup_stm32f10x_md.s
    CMSIS/: system_stm32f10x.c
  group StdPeriph_Driver
    StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_flash.c misc.c
  group MYDRIVER
    MYDRIVER/: drv_pwm.c drv_adc.c
  group MYUSER
    MYUSER/: mydev.c mainprocess.c my_rtt_debug.c
  group SEGGER_RTT
    SEGGER_RTT/: SEGGER_RTT.c

# IAR project auto_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
STM32F10X_MD
  ICCARM.CCIncludePath2: CMSIS
StdPeriph_Driver\inc
MYDRIVER
MYUSER
SEGGER_RTT
Core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: auto_test.srec
  ILINK.IlinkOutputFile: auto_test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  group Core
    Core/: main.c startup_stm32f10x_md.s stm32f10x_it.c
    CMSIS/: system_stm32f10x.c
  group MYDRIVER
    MYDRIVER/: drv_adc.c drv_pwm.c
  group MYUSER
    MYUSER/: mainprocess.c my_rtt_debug.c mydev.c
  group SEGGER_RTT
    SEGGER_RTT/: SEGGER_RTT.c
  group StdPeriph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
